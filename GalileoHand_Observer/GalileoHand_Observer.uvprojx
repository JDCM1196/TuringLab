# Keil uVision project GalileoHand_Observer.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK20DX64xxx7 NXP
  pack: Keil.Kinetis_K20_DFP.1.5.2
  cpu: IRAM(0x20000000,0x00002000) IRAM2(0x1FFFE000,0x00002000) IROM(0x00000000,0x00010000) IROM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: GalileoHand_Observer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group Source Group 1
    ./: main.c
  group New Group
    ../GalileoHand_TeensyKeil/: drivers.c finger.c drivers.h finger.h
software components: CMSIS:DSP 1.5.1, Device:Startup 1.0.0
